# Keil uVision project AylaLoader.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(100000000) ELITTLE
  output: ayla_loader +hex
  AfterMake: fromelf --bin --output=.\Objects\ayla_loader.bin .\Objects\ayla_loader.axf
  c flags: Optim=1 wLevel=2
  c define: STM32F411xE USE_HAL_DRIVER AYLA_KEIL LOADER_FUNCTION
  c include: ..\STM32F4xx_DFP_2.3.0\Drivers\STM32F4xx_HAL_Driver\Inc;..\XApp;..\ST
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group loader
    ../XApp/: loader.c
  group ST
    ../STM32F4xx_DFP_2.3.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c
    ../ST/: system_stm32f4xx.c startup_stm32f411xe.s
  group keil
    ../XApp/: bb_entry.s
