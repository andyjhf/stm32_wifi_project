# Keil uVision project AylaDeviceApp.uvprojx, settings and files
target AylaDeviceApp(Release) (ARM-ADS)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ayla_device_app +hex
  AfterMake: fromelf --bin --output=.\Objects\ayla_device.bin .\Objects\ayla_device.axf
  AfterMake: ..\XApp\img_pkg_win.exe -i .\Objects\ayla_device.bin -o .\Objects\ayla_device.img -t stm32f4
  c flags: Optim=4 wLevel=2
  c define: STM32F411xE USE_HAL_DRIVER AYLA_WIFI_JOIN AYLA_WIFI_DEMO AYLA_KEIL __NO_EMBEDDED_ASM DEMO_SCHED_LIB DEMO_TIME_LIB AYLA_SCHED AYLA_TIME DEMO_CONF AYLA_CONF AYLA_UART DEMO_UART DEMO_IMG_MGMT AYLA_HOST_OTA
  c include: ..\STM32F4xx_DFP_2.3.0\Drivers\STM32F4xx_HAL_Driver\Inc;..\STM32F4xx_DFP_2.3.0\Drivers\CMSIS\Include;..\STM32F4xx_DFP_2.3.0\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Ayla\Inc;..\ST;..\XApp
  memory RVCT4: ROM 0x8020000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group README
    ../XApp/: README.txt
  group Drivers/STM32F4xx_HAL_Driver
    ../STM32F4xx_DFP_2.3.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_dma.c stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rcc_ex.c
  group Drivers/MDK-ARM
    ../ST/: startup_stm32f411xe.s
  group Drivers/Board_Inc
    ../ST/: driver_stm32f411ce.h stm32f4xx_hal_conf.h stm32f4xx_it.h driver_utility.h driver_gpio.h driver_rcc.h driver_uart1.h driver_uart2.h driver_uart6.h driver_iwdg.h driver_i2c1.h driver_rtc.h
  group Drivers/Board
    ../ST/: stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c driver_utility.c driver_gpio.c driver_rcc.c driver_uart1.c driver_uart2.c driver_uart6.c driver_iwdg.c driver_i2c1.c driver_rtc.c
  group Ayla_Src
    ../Ayla/Src/: ayla_utility.c ayla_protocol.c ayla_conf_access.c ayla_clock.c ayla_props.c ayla_serial.c ayla_sched.c ayla_schedeval.c ayla_uart.c ayla_host_ota.c
  group Ayla_Inc
    ../Ayla/Inc/: ayla_utility.h ayla_protocol.h ayla_conf_access.h ayla_clock.h ayla_props.h ayla_sched.h ayla_schedeval.h ayla_serial.h ayla_uart.h ayla_xxx.h ayla_host_ota.h ayla_host_ota_internal.h
  group XApp
    ../XApp/: flash_layout.h MUtility.h MUtility.cpp MSerial.h MSerial.cpp demo_img_mgmt.h demo_img_mgmt.cpp XTaskComWifi.h XTaskComWifi.cpp XTaskHost.h XTaskHost.cpp XTaskComERV.h XTaskComERV.cpp XTaskSensorData.h XTaskSensorData.cpp XAppDef.h XApp.h XApp.cpp main .cpp
target AylaDeviceApp(Debug) (ARM-ADS)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: as above
  output: AlyaDevice_Debug +hex
  c flags: Optim=1 wLevel=2
  c define: DEBUG STM32F411xE USE_HAL_DRIVER AYLA_WIFI_JOIN AYLA_WIFI_DEMO AYLA_KEIL __NO_EMBEDDED_ASM DEMO_SCHED_LIB DEMO_TIME_LIB AYLA_SCHED AYLA_TIME DEMO_CONF AYLA_CONF AYLA_UART DEMO_UART
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
